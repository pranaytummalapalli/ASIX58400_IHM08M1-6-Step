# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE-Nucleo Configuration (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RE-Nucleo Configuration
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc;..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM08M1;..\..\..\..\..\..\Drivers\BSP\Components\l6398;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\CMSIS\Include\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal.c stm32f4xx_hal_spi.c
  group Middlewares/MC_6Step_Lib
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/l6398/: l6398.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM08M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM08M1/: X-NUCLEO-IHM08M1.c
  group User
    ../../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main_F401.c stm32F401_nucleo_ihm08m1.c
    ../../Inc/: MC_SixStep_param.h
target STM32F401RE-Nucleo - COMM (ARM-ADS)
  device: STM32F401VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401RE-Nucleo - COMM
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,UART_COMM
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc;..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM08M1;..\..\..\..\..\..\Drivers\BSP\Components\l6398;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 3.40.0, Device:Startup 2.1.0
